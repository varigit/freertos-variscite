# IAR project ethosu_apps_rpmsg.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMX9352_M33 NXP MIMX9352_M33
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 58
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; CPU_MIMX9352DVUXM_cm33; ARM_MATH_CM33; __FPU_PRESENT=1; PRINTF_ADVANCED_ENABLE=1; SDK_DEBUGCONSOLE=1; ETHOSU_ARCH=u65; ETHOSU65=1; TF_LITE_STATIC_MEMORY; CMSIS_NN; SDK_OS_FREE_RTOS; SERIAL_PORT_TYPE_UART=1; MCUXPRESSO_SDK
  ICCARM.CCDiagSuppress: Pe830,Go003,Pa050,Pa082,Pa084,Pa093,Pe069,Pe111,Pe161,Pe174,Pe177,Pe186,Pe188,Pe550,Pe611,Pe997,Pe1444
  ICCARM.IExtraOptions: --enable_restrict
  ICCARM.CCIncludePath2: ..; ../../../../../middleware/ethos-u-core-software/board/mcimx93evk; ../../../../../middleware/multicore/rpmsg_lite/lib/include/platform/imx93_m33; ../../../../../middleware/multicore/rpmsg_lite/lib/include; ../../../../../middleware/multicore/rpmsg_lite/lib/include/environment/freertos; ../../../../../CMSIS/Core/Include; ../../../../../devices/MIMX9352/drivers; ../../../../../middleware/eiq/tensorflow-lite; ../../../../../rtos/freertos/freertos-kernel/include; ../../../../../rtos/freertos/freertos-kernel/portable/IAR/ARM_CM33_NTZ/non_secure; ../source; ../../../../../middleware/ethos-u-core-software/applications/inference_process/include; ../../../../../middleware/ethos-u-core-software/lib/arm_profiler/include; ../../../../../middleware/ethos-u-core-software/lib/crc/include; ../../../../../middleware/ethos-u-core-software/lib/ethosu_log/include; ../../../../../middleware/ethos-u-core-software/lib/ethosu_monitor/include; ../../../../../middleware/ethos-u-core-software/core_driver/include; ../../../../../devices/MIMX9352; ../../../../../devices/MIMX9352/utilities/str; ../../../../../devices/MIMX9352/utilities/debug_console; ../../../../../components/uart; ../../../../../components/serial_manager; ../../../../../components/lists; ../../../../../middleware/eiq/tensorflow-lite/third_party/flatbuffers/include; ../../../../../middleware/eiq/tensorflow-lite/third_party/gemmlowp; ../../../../../middleware/eiq/tensorflow-lite/third_party/ruy; ../../../../../middleware/eiq/tensorflow-lite/third_party/cmsis; ../../../../../middleware/eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Include; ../../../../../middleware/eiq/tensorflow-lite/third_party/cmsis/CMSIS/Core/Include; ../../../../../middleware/eiq/tensorflow-lite/third_party/cmsis/CMSIS/DSP/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  AARM.AUserIncludes: ..
  ILINK.IlinkOutputFile: ethosu_apps_rpmsg.out
  ILINK.IlinkConfigDefines: __stack_size__=0x1000; __heap_size__=0x2000
  ILINK.IlinkIcfFile: MIMX9352_cm33_ram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MIMX9352DVUXM_cm33; ARM_MATH_CM33; __FPU_PRESENT=1; PRINTF_ADVANCED_ENABLE=1; SDK_DEBUGCONSOLE=1; ETHOSU_ARCH=u65; ETHOSU65=1; TF_LITE_STATIC_MEMORY; CMSIS_NN; SDK_OS_FREE_RTOS; SERIAL_PORT_TYPE_UART=1; MCUXPRESSO_SDK
  ICCARM.CCOptLevel: 1
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  group source
    ../source/: ethosu_apps_rpmsg.cpp src.h hardware_init.c app.h
    ../: rpmsg_config.h FreeRTOSConfig.h ethosu_core_interface.h
    ../../../../../middleware/ethos-u-core-software/include/: ethosu_core_interface.h
    ../../../../../middleware/ethos-u-core-software/applications/inference_process/include/: inference_process.hpp inference_parser.hpp
    ../../../../../middleware/ethos-u-core-software/applications/inference_process/src/: inference_process.cpp
    ../../../../../middleware/ethos-u-core-software/lib/arm_profiler/include/: arm_profiler.hpp
    ../../../../../middleware/ethos-u-core-software/lib/arm_profiler/src/: arm_profiler.cpp
    ../../../../../middleware/ethos-u-core-software/lib/crc/include/: crc.hpp
    ../../../../../middleware/ethos-u-core-software/lib/ethosu_monitor/src/: ethosu_monitor.cpp
    ../../../../../middleware/ethos-u-core-software/lib/ethosu_monitor/include/: ethosu_monitor.hpp
    ../../../../../middleware/ethos-u-core-software/core_driver/src/: ethosu_config_u65.h ethosu_device.h ethosu_log.h ethosu_interface.h ethosu65_interface.h ethosu_device_u55_u65.c ethosu_driver.c ethosu_pmu.c
    ../../../../../middleware/ethos-u-core-software/core_driver/include/: ethosu_driver.h ethosu_types.h pmu_ethosu.h
  group source/ethosu_log
    ../../../../../middleware/ethos-u-core-software/lib/ethosu_log/include/: ethosu_log.h
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
    ./: retarget.c
  group doc
    ../../../../../middleware/ethos-u-core-software/: readme.txt LICENSE.txt SW-Content-Register.txt
  group rpmsg_lite/include
    ../../../../../middleware/multicore/rpmsg_lite/lib/include/: rpmsg_lite.h rpmsg_ns.h llist.h rpmsg_default_config.h virtio_ring.h virtqueue.h rpmsg_compiler.h rpmsg_env.h rpmsg_queue.h
  group rpmsg_lite/include/platform/imx93_m33
    ../../../../../middleware/multicore/rpmsg_lite/lib/include/platform/imx93_m33/: rpmsg_platform.h
  group rpmsg_lite/include/environment/freertos
    ../../../../../middleware/multicore/rpmsg_lite/lib/include/environment/freertos/: rpmsg_env_specific.h
  group rpmsg_lite/rpmsg_lite
    ../../../../../middleware/multicore/rpmsg_lite/lib/rpmsg_lite/: rpmsg_lite.c rpmsg_ns.c rpmsg_queue.c
  group rpmsg_lite/rpmsg_lite/porting/platform/imx93_m33
    ../../../../../middleware/multicore/rpmsg_lite/lib/rpmsg_lite/porting/platform/imx93_m33/: rpmsg_platform.c
  group rpmsg_lite/rpmsg_lite/porting/environment
    ../../../../../middleware/multicore/rpmsg_lite/lib/rpmsg_lite/porting/environment/: rpmsg_env_freertos.c
  group rpmsg_lite/common
    ../../../../../middleware/multicore/rpmsg_lite/lib/common/: llist.c
  group rpmsg_lite/virtio
    ../../../../../middleware/multicore/rpmsg_lite/lib/virtio/: virtqueue.c
  group freertos/freertos-kernel
    ../../../../../rtos/freertos/freertos-kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos-kernel/portable
    ../../../../../rtos/freertos/freertos-kernel/portable/: readme.txt
  group freertos/freertos-kernel/portable/MemMang
    ../../../../../rtos/freertos/freertos-kernel/portable/MemMang/: heap_4.c ReadMe.url
  group freertos/freertos-kernel/portable/IAR/ARM_CM33_NTZ/non_secure
    ../../../../../rtos/freertos/freertos-kernel/portable/IAR/ARM_CM33_NTZ/non_secure/: port.c portasm.h portasm.s portmacro.h portmacrocommon.h
  group freertos/freertos-kernel/include
    ../../../../../rtos/freertos/freertos-kernel/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stdint.readme stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
  group CMSIS
    ../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm33.h mpu_armv8.h tz_context.h
  group drivers
    ../../../../../devices/MIMX9352/drivers/: fsl_mu.h fsl_mu.c fsl_rgpio.h fsl_rgpio.c fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_lpuart.h fsl_lpuart.c fsl_iomuxc.h fsl_cache.c fsl_cache.h
  group eiq/tensorflow-lite
    ../../../../../middleware/eiq/tensorflow-lite/: AUTHORS LICENSE NOTICE ChangeLogKSDK.txt readme.txt AUTHORS LICENSE NOTICE ChangeLogKSDK.txt readme.txt
  group eiq/tensorflow-lite/tensorflow/lite
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/: context_util.h portable_type_to_tflitetype.h
  group eiq/tensorflow-lite/tensorflow/lite/c
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/c/: common.h common.cpp builtin_op_data.h c_api_types.h
  group eiq/tensorflow-lite/tensorflow/lite/core/api
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/core/api/: error_reporter.h flatbuffer_conversions.h op_resolver.h tensor_utils.h error_reporter.cpp flatbuffer_conversions.cpp op_resolver.cpp tensor_utils.cpp
  group eiq/tensorflow-lite/tensorflow/lite/kernels
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/kernels/: kernel_util.h kernel_utils.cpp op_macros.h padding.h
  group eiq/tensorflow-lite/tensorflow/lite/kernels/internal
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/kernels/internal/: common.h compatibility.h cppmath.h max.h min.h portable_tensor.h portable_tensor_utils.h quantization_util.h quantization_util.cpp runtime_shape.h strided_slice_logic.h tensor_ctypes.h types.h
  group eiq/tensorflow-lite/tensorflow/lite/kernels/internal/optimized
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/kernels/internal/optimized/: neon_check.h
  group eiq/tensorflow-lite/tensorflow/lite/kernels/internal/reference
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/kernels/internal/reference/: add.h add_n.h arg_min_max.h batch_to_space_nd.h binary_function.h broadcast_args.h broadcast_to.h ceil.h comparisons.h concatenation.h conv.h cumsum.h depth_to_space.h depthwiseconv_float.h depthwiseconv_uint8.h dequantize.h div.h elu.h exp.h fill.h floor.h floor_div.h floor_mod.h fully_connected.h hard_swish.h l2normalization.h leaky_relu.h log_softmax.h logistic.h maximum_minimum.h mul.h neg.h pad.h pooling.h portable_tensor_utils_impl.h prelu.h process_broadcast_shapes.h quantize.h reduce.h requantize.h resize_bilinear.h resize_nearest_neighbor.h round.h select.h slice.h softmax.h space_to_batch_nd.h space_to_depth.h strided_slice.h sub.h tanh.h transpose.h transpose_conv.h portable_tensor_utils.cpp
  group eiq/tensorflow-lite/tensorflow/lite/kernels/internal/reference/integer_ops
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/kernels/internal/reference/integer_ops/: add.h conv.h depthwise_conv.h fully_connected.h l2normalization.h logistic.h mean.h mul.h pooling.h tanh.h transpose_conv.h
  group eiq/tensorflow-lite/tensorflow/lite/micro
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/micro/: all_ops_resolver.cpp all_ops_resolver.h compatibility.h debug_log.cpp debug_log.h fake_micro_context.cpp fake_micro_context.h flatbuffer_utils.cpp flatbuffer_utils.h memory_helpers.cpp memory_helpers.h micro_allocation_info.cpp micro_allocation_info.h micro_allocator.cpp micro_allocator.h micro_arena_constants.h micro_context.cpp micro_context.h micro_error_reporter.cpp micro_error_reporter.h micro_graph.cpp micro_graph.h micro_interpreter.cpp micro_interpreter.h micro_log.cpp micro_log.h micro_mutable_op_resolver.h micro_op_resolver.h micro_profiler.cpp micro_profiler.h micro_resource_variable.cpp micro_resource_variable.h micro_string.cpp micro_string.h micro_time.cpp micro_time.h micro_utils.cpp micro_utils.h recording_micro_allocator.cpp recording_micro_allocator.h micro_string.h micro_string.cpp
  group eiq/tensorflow-lite/tensorflow/lite/micro/kernels
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/micro/kernels/: activation_utils.h activations.h add.h circular_buffer.h conv.h depthwise_conv.h dequantize.h ethosu.h fully_connected.h hard_swish.h kernel_runner.h kernel_util.h leaky_relu.h logical.h logistic.h lstm_eval.h lstm_shared.h micro_ops.h micro_tensor_utils.h micro_utils.h mul.h pooling.h prelu.h quantize.h reduce.h softmax.h sub.h svdf.h activations_common.cpp add_common.cpp add_n.cpp arg_min_max.cpp assign_variable.cpp batch_to_space_nd.cpp broadcast_args.cpp broadcast_to.cpp call_once.cpp cast.cpp ceil.cpp circular_buffer.cpp circular_buffer_common.cpp comparisons.cpp concatenation.cpp conv_common.cpp cumsum.cpp depth_to_space.cpp depthwise_conv_common.cpp dequantize.cpp dequantize_common.cpp detection_postprocess.cpp div.cpp elementwise.cpp elu.cpp exp.cpp expand_dims.cpp fill.cpp floor_div.cpp floor_mod.cpp fully_connected_common.cpp gather.cpp gather_nd.cpp hard_swish.cpp hard_swish_common.cpp if.cpp kernel_util.cpp l2_pool_2d.cpp l2norm.cpp leaky_relu_common.cpp log_softmax.cpp logical.cpp logical_common.cpp logistic_common.cpp maximum_minimum.cpp micro_tensor_utils.cpp mirror_pad.cpp mul_common.cpp neg.cpp pack.cpp pooling_common.cpp prelu.cpp prelu_common.cpp quantize_common.cpp read_variable.cpp reduce_common.cpp resize_bilinear.cpp resize_nearest_neighbor.cpp round.cpp select.cpp shape.cpp slice.cpp softmax_common.cpp space_to_batch_nd.cpp space_to_depth.cpp split.cpp split_v.cpp squared_difference.cpp squeeze.cpp sub_common.cpp svdf_common.cpp tanh.cpp transpose.cpp unpack.cpp var_handle.cpp while.cpp zeros_like.cpp activations.cpp floor.cpp leaky_relu.cpp logistic.cpp lstm_eval.cpp pad.cpp quantize.cpp reduce.cpp reshape.cpp strided_slice.cpp sub.cpp transpose_conv.cpp unidirectional_sequence_lstm.cpp
  group eiq/tensorflow-lite/tensorflow/lite/micro/kernels/cmsis_nn
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/micro/kernels/cmsis_nn/: add.cpp conv.cpp depthwise_conv.cpp fully_connected.cpp mul.cpp pooling.cpp softmax.cpp svdf.cpp
  group eiq/tensorflow-lite/tensorflow/lite/micro/kernels/ethos_u
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/micro/kernels/ethos_u/: ethosu.cpp
  group eiq/tensorflow-lite/tensorflow/lite/micro/arena_allocator
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/micro/arena_allocator/: ibuffer_allocator.h non_persistent_arena_buffer_allocator.h persistent_arena_buffer_allocator.h recording_single_arena_buffer_allocator.h single_arena_buffer_allocator.h non_persistent_arena_buffer_allocator.cpp persistent_arena_buffer_allocator.cpp recording_single_arena_buffer_allocator.cpp single_arena_buffer_allocator.cpp
  group eiq/tensorflow-lite/tensorflow/lite/micro/memory_planner
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/micro/memory_planner/: greedy_memory_planner.h linear_memory_planner.h memory_plan_struct.h micro_memory_planner.h non_persistent_buffer_planner_shim.h greedy_memory_planner.cpp linear_memory_planner.cpp non_persistent_buffer_planner_shim.cpp
  group eiq/tensorflow-lite/tensorflow/lite/schema
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/schema/: schema_utils.cpp schema_generated.h schema_utils.h
  group eiq/tensorflow-lite/third_party/flatbuffers
    ../../../../../middleware/eiq/tensorflow-lite/third_party/flatbuffers/: readme.md LICENSE.txt
  group eiq/tensorflow-lite/third_party/flatbuffers/include/flatbuffers
    ../../../../../middleware/eiq/tensorflow-lite/third_party/flatbuffers/include/flatbuffers/: allocator.h array.h base.h buffer.h buffer_ref.h default_allocator.h detached_buffer.h flatbuffer_builder.h flatbuffers.h flexbuffers.h stl_emulation.h strings.h struct.h table.h util.h vector.h vector_downward.h verifier.h
  group eiq/tensorflow-lite/third_party/gemmlowp
    ../../../../../middleware/eiq/tensorflow-lite/third_party/gemmlowp/: LICENSE README.md
  group eiq/tensorflow-lite/third_party/gemmlowp/fixedpoint
    ../../../../../middleware/eiq/tensorflow-lite/third_party/gemmlowp/fixedpoint/: fixedpoint.h
  group eiq/tensorflow-lite/third_party/gemmlowp/internal
    ../../../../../middleware/eiq/tensorflow-lite/third_party/gemmlowp/internal/: detect_platform.h
  group eiq/tensorflow-lite/third_party/ruy
    ../../../../../middleware/eiq/tensorflow-lite/third_party/ruy/: LICENSE README.md
  group eiq/tensorflow-lite/third_party/ruy/ruy/profiler
    ../../../../../middleware/eiq/tensorflow-lite/third_party/ruy/ruy/profiler/: instrumentation.h
  group eiq/tensorflow-lite/third_party/cmsis
    ../../../../../middleware/eiq/tensorflow-lite/third_party/cmsis/: LICENSE.txt README.md
  group eiq/tensorflow-lite/third_party/cmsis/CMSIS/Core/Include
    ../../../../../middleware/eiq/tensorflow-lite/third_party/cmsis/CMSIS/Core/Include/: cachel1_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv81mml.h core_armv8mbl.h core_armv8mml.h core_cm0.h core_cm0plus.h core_cm1.h core_cm23.h core_cm3.h core_cm33.h core_cm35p.h core_cm4.h core_cm55.h core_cm7.h core_cm85.h core_sc000.h core_sc300.h core_star.h core_starmc1.h mpu_armv7.h mpu_armv8.h pac_armv81.h pmu_armv8.h tz_context.h
  group eiq/tensorflow-lite/third_party/cmsis/CMSIS/DSP/Include
    ../../../../../middleware/eiq/tensorflow-lite/third_party/cmsis/CMSIS/DSP/Include/: arm_common_tables.h arm_common_tables_f16.h arm_const_structs.h arm_const_structs_f16.h arm_helium_utils.h arm_math.h arm_math_f16.h arm_math_memory.h arm_math_types.h arm_math_types_f16.h arm_mve_tables.h arm_mve_tables_f16.h arm_vec_math.h arm_vec_math_f16.h
  group eiq/tensorflow-lite/third_party/cmsis/CMSIS/DSP/Include/dsp
    ../../../../../middleware/eiq/tensorflow-lite/third_party/cmsis/CMSIS/DSP/Include/dsp/: basic_math_functions.h basic_math_functions_f16.h bayes_functions.h bayes_functions_f16.h complex_math_functions.h complex_math_functions_f16.h controller_functions.h controller_functions_f16.h distance_functions.h distance_functions_f16.h fast_math_functions.h fast_math_functions_f16.h filtering_functions.h filtering_functions_f16.h interpolation_functions.h interpolation_functions_f16.h matrix_functions.h matrix_functions_f16.h none.h quaternion_math_functions.h statistics_functions.h statistics_functions_f16.h support_functions.h support_functions_f16.h svm_defines.h svm_functions.h svm_functions_f16.h transform_functions.h transform_functions_f16.h utils.h
  group eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN
    ../../../../../middleware/eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/: README.md
  group eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Include
    ../../../../../middleware/eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Include/: arm_nn_math_types.h arm_nn_tables.h arm_nn_types.h arm_nnfunctions.h arm_nnsupportfunctions.h
  group eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Source/ActivationFunctions
    ../../../../../middleware/eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Source/ActivationFunctions/: arm_nn_activations_q15.c arm_nn_activations_q7.c arm_relu6_s8.c arm_relu_q15.c arm_relu_q7.c
  group eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Source/BasicMathFunctions
    ../../../../../middleware/eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Source/BasicMathFunctions/: arm_elementwise_add_s16.c arm_elementwise_add_s8.c arm_elementwise_mul_s16.c arm_elementwise_mul_s8.c
  group eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Source/ConcatenationFunctions
    ../../../../../middleware/eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Source/ConcatenationFunctions/: arm_concatenation_s8_w.c arm_concatenation_s8_x.c arm_concatenation_s8_y.c arm_concatenation_s8_z.c
  group eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Source/ConvolutionFunctions
    ../../../../../middleware/eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Source/ConvolutionFunctions/: arm_convolve_1_x_n_s8.c arm_convolve_1x1_HWC_q7_fast_nonsquare.c arm_convolve_1x1_s8_fast.c arm_convolve_HWC_q15_basic.c arm_convolve_HWC_q15_fast.c arm_convolve_HWC_q15_fast_nonsquare.c arm_convolve_HWC_q7_RGB.c arm_convolve_HWC_q7_basic.c arm_convolve_HWC_q7_basic_nonsquare.c arm_convolve_HWC_q7_fast.c arm_convolve_HWC_q7_fast_nonsquare.c arm_convolve_fast_s16.c arm_convolve_s16.c arm_convolve_s8.c arm_convolve_wrapper_s16.c arm_convolve_wrapper_s8.c arm_depthwise_conv_3x3_s8.c arm_depthwise_conv_s16.c arm_depthwise_conv_s8.c arm_depthwise_conv_s8_opt.c arm_depthwise_conv_u8_basic_ver1.c arm_depthwise_conv_wrapper_s8.c arm_depthwise_separable_conv_HWC_q7.c arm_depthwise_separable_conv_HWC_q7_nonsquare.c arm_nn_depthwise_conv_s8_core.c arm_nn_mat_mult_kernel_q7_q15.c arm_nn_mat_mult_kernel_q7_q15_reordered.c arm_nn_mat_mult_kernel_s8_s16.c arm_nn_mat_mult_s8.c
  group eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Source/FullyConnectedFunctions
    ../../../../../middleware/eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Source/FullyConnectedFunctions/: arm_fully_connected_mat_q7_vec_q15.c arm_fully_connected_mat_q7_vec_q15_opt.c arm_fully_connected_q15.c arm_fully_connected_q15_opt.c arm_fully_connected_q7.c arm_fully_connected_q7_opt.c arm_fully_connected_s16.c arm_fully_connected_s8.c
  group eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Source/NNSupportFunctions
    ../../../../../middleware/eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Source/NNSupportFunctions/: arm_nn_accumulate_q7_to_q15.c arm_nn_add_q7.c arm_nn_depthwise_conv_nt_t_padded_s8.c arm_nn_depthwise_conv_nt_t_s8.c arm_nn_mat_mul_core_1x_s8.c arm_nn_mat_mul_core_4x_s8.c arm_nn_mat_mul_kernel_s16.c arm_nn_mat_mult_nt_t_s8.c arm_nn_mult_q15.c arm_nn_mult_q7.c arm_nn_vec_mat_mult_t_s16.c arm_nn_vec_mat_mult_t_s8.c arm_nn_vec_mat_mult_t_svdf_s8.c arm_nntables.c arm_q7_to_q15_no_shift.c arm_q7_to_q15_reordered_no_shift.c arm_q7_to_q15_reordered_with_offset.c arm_q7_to_q15_with_offset.c
  group eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Source/PoolingFunctions
    ../../../../../middleware/eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Source/PoolingFunctions/: arm_avgpool_s16.c arm_avgpool_s8.c arm_max_pool_s16.c arm_max_pool_s8.c arm_pool_q7_HWC.c
  group eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Source/ReshapeFunctions
    ../../../../../middleware/eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Source/ReshapeFunctions/: arm_reshape_s8.c
  group eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Source/SVDFunctions
    ../../../../../middleware/eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Source/SVDFunctions/: arm_svdf_s8.c arm_svdf_state_s16_s8.c
  group eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Source/SoftmaxFunctions
    ../../../../../middleware/eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Source/SoftmaxFunctions/: arm_nn_softmax_common_s8.c arm_softmax_q15.c arm_softmax_q7.c arm_softmax_s16.c arm_softmax_s8.c arm_softmax_s8_s16.c arm_softmax_u8.c arm_softmax_with_batch_q7.c
  group remoteproc
    ../source/: rsc_table.c rsc_table.h remoteproc.h
  group device
    ../../../../../devices/MIMX9352/: fsl_device_registers.h MIMX9352_cm33.h MIMX9352_cm33_features.h system_MIMX9352_cm33.c system_MIMX9352_cm33.h
  group utilities
    ../../../../../devices/MIMX9352/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MIMX9352/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MIMX9352/utilities/: fsl_assert.c
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/serial_manager
    ../../../../../components/serial_manager/: fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group startup
    ../../../../../devices/MIMX9352/iar/: startup_MIMX9352_cm33.s
