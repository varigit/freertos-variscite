# IAR project cmsis_lpspi_int_b2b_transfer_master.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMX9352_M33 NXP MIMX9352_M33
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 58
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; CPU_MIMX9352DVUXM_cm33; SDK_I2C_BASED_COMPONENT_USED=1; BOARD_USE_ADP5585=1; MCUXPRESSO_SDK
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../../../../../../devices/MIMX9352/utilities/str; ../../../../../../../devices/MIMX9352/utilities/debug_console_lite; ../../../../../../../devices/MIMX9352/drivers; ../../../../../../../components/adp5585; ../../../../../../../devices/MIMX9352/cmsis_drivers; ../../../../../../../devices/MIMX9352; ../../../../../../../components/uart; ../../../../../../../components/lists; ../../../../../../../CMSIS/Core/Include; ../../../../../../../devices/MIMX9352/drivers/dma3; ../../../../../../../CMSIS/Driver/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  OBJCOPY.OOCOutputFile: sdk20-app.bin
  ILINK.IlinkOutputFile: cmsis_lpspi_int_b2b_transfer_master.out
  ILINK.IlinkIcfFile: MIMX9352_cm33_ram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MIMX9352DVUXM_cm33; SDK_I2C_BASED_COMPONENT_USED=1; BOARD_USE_ADP5585=1; MCUXPRESSO_SDK
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  group source
    ../: cmsis_lpspi_int_b2b_transfer_master.c
  group board
    ../: pin_mux.c pin_mux.h RTE_Device.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group utilities
    ../../../../../../../devices/MIMX9352/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../../devices/MIMX9352/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c
  group drivers
    ../../../../../../../devices/MIMX9352/drivers/: fsl_lpi2c.c fsl_lpi2c.h fsl_clock.h fsl_clock.c fsl_lpuart.h fsl_lpuart.c fsl_lpspi.c fsl_lpspi.h fsl_lpspi_edma.h fsl_lpspi_edma.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_iomuxc.h fsl_rgpio.h fsl_rgpio.c fsl_cache.c fsl_cache.h fsl_sentinel.h fsl_sentinel.c fsl_memory.h
    ../../../../../../../devices/MIMX9352/cmsis_drivers/: fsl_lpspi_cmsis.h fsl_lpspi_cmsis.c
    ../../../../../../../devices/MIMX9352/drivers/dma3/: fsl_edma.h fsl_edma.c
  group components/adp5585
    ../../../../../../../components/adp5585/: fsl_adp5585.h fsl_adp5585.c
  group device
    ../../../../../../../devices/MIMX9352/: fsl_device_registers.h MIMX9352_cm33.h MIMX9352_cm33_features.h system_MIMX9352_cm33.c system_MIMX9352_cm33.h
  group component/uart
    ../../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/lists
    ../../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group startup
    ../../../../../../../devices/MIMX9352/iar/: startup_MIMX9352_cm33.s
  group CMSIS
    ../../../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm33.h mpu_armv8.h tz_context.h
  group CMSIS_driver
    ../../../../../../../CMSIS/Driver/Include/: Driver_SPI.h Driver_Common.h
