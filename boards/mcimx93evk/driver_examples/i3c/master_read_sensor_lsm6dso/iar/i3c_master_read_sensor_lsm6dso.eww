<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>i3c_master_read_sensor_lsm6dso</project>
        <configuration>debug</configuration>
      </member>
      <member>
        <project>i3c_master_read_sensor_lsm6dso</project>
        <configuration>release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>debug</name>
      <member>
        <project>i3c_master_read_sensor_lsm6dso</project>
        <configuration>debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>release</name>
      <member>
        <project>i3c_master_read_sensor_lsm6dso</project>
        <configuration>release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
  <project>
    <path>$WS_DIR$/i3c_master_read_sensor_lsm6dso.ewp</path>
  </project>
</workspace>
