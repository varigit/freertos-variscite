# IAR project enet_txrx_ptp1588_transfer.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMX9352_M33 NXP MIMX9352_M33
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 58
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; ENET_ENHANCEDBUFFERDESCRIPTOR_MODE=1; FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE; PHY_STABILITY_DELAY_US=500000U; CPU_MIMX9352DVUXM_cm33; SDK_I2C_BASED_COMPONENT_USED=1; BOARD_USE_PCAL6524=1; PRINTF_ADVANCED_ENABLE=1; SERIAL_PORT_TYPE_UART=1; MCUXPRESSO_SDK
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../../../../../components/phy/device/phyrtl8211f; ../../../../../../devices/MIMX9352/drivers; ../../../../../../components/pcal6524; ../../../../../../components/silicon_id; ../../../../../../components/silicon_id/socs; ../../../../../../devices/MIMX9352; ../../../../../../devices/MIMX9352/utilities/str; ../../../../../../devices/MIMX9352/utilities/debug_console; ../../../../../../components/uart; ../../../../../../components/serial_manager; ../../../../../../components/lists; ../../../../../../components/phy; ../../../../../../CMSIS/Core/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  OBJCOPY.OOCOutputFile: sdk20-app.bin
  ILINK.IlinkOutputFile: enet_txrx_ptp1588_transfer.out
  ILINK.IlinkConfigDefines: __stack_size__=0x1000; __heap_size__=0x1000
  ILINK.IlinkIcfFile: MIMX9352_cm33_ram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; ENET_ENHANCEDBUFFERDESCRIPTOR_MODE=1; FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE; PHY_STABILITY_DELAY_US=500000U; CPU_MIMX9352DVUXM_cm33; SDK_I2C_BASED_COMPONENT_USED=1; BOARD_USE_PCAL6524=1; PRINTF_ADVANCED_ENABLE=1; SERIAL_PORT_TYPE_UART=1; MCUXPRESSO_SDK
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  group source
    ../: enet_txrx_ptp1588_transfer.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group component/phy
    ../../../../../../components/phy/device/phyrtl8211f/: fsl_phyrtl8211f.h fsl_phyrtl8211f.c
    ../../../../../../components/phy/: fsl_phy.h
  group component/silicon_id
    ../../../../../../components/silicon_id/: fsl_silicon_id.c fsl_silicon_id.h
    ../../../../../../components/silicon_id/socs/imx93/: fsl_silicon_id_soc.c
    ../../../../../../components/silicon_id/socs/: fsl_silicon_id_soc.h
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/serial_manager
    ../../../../../../components/serial_manager/: fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group drivers
    ../../../../../../devices/MIMX9352/drivers/: fsl_lpi2c.c fsl_lpi2c.h fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_clock.h fsl_clock.c fsl_enet.h fsl_enet.c fsl_lpuart.h fsl_lpuart.c fsl_iomuxc.h fsl_rgpio.h fsl_rgpio.c fsl_cache.c fsl_cache.h fsl_sentinel.h fsl_sentinel.c fsl_memory.h
  group components/pcal6524
    ../../../../../../components/pcal6524/: fsl_pcal6524.h fsl_pcal6524.c
  group device
    ../../../../../../devices/MIMX9352/: fsl_device_registers.h MIMX9352_cm33.h MIMX9352_cm33_features.h system_MIMX9352_cm33.c system_MIMX9352_cm33.h
  group utilities
    ../../../../../../devices/MIMX9352/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../devices/MIMX9352/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../devices/MIMX9352/utilities/: fsl_assert.c
  group startup
    ../../../../../../devices/MIMX9352/iar/: startup_MIMX9352_cm33.s
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm33.h mpu_armv8.h tz_context.h
