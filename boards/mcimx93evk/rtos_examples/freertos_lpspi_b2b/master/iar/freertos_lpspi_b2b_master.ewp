# IAR project freertos_lpspi_b2b_master.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMX9352_M33 NXP MIMX9352_M33
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 58
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; CPU_MIMX9352DVUXM_cm33; SDK_I2C_BASED_COMPONENT_USED=1; BOARD_USE_ADP5585=1; SERIAL_PORT_TYPE_UART=1; SDK_OS_FREE_RTOS; MCUXPRESSO_SDK
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../../../../../rtos/freertos/freertos-kernel/portable/IAR/ARM_CM33_NTZ/non_secure; ../../../../../../devices/MIMX9352/drivers; ../../../../../../components/adp5585; ../../../../../../devices/MIMX9352; ../../../../../../devices/MIMX9352/utilities/str; ../../../../../../devices/MIMX9352/utilities/debug_console; ../../../../../../components/uart; ../../../../../../components/serial_manager; ../../../../../../components/lists; ../../../../../../rtos/freertos/freertos-kernel/include; ../../../../../../CMSIS/Core/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  AARM.AUserIncludes: ..
  OBJCOPY.OOCOutputFile: sdk20-app.bin
  ILINK.IlinkOutputFile: freertos_lpspi_b2b_master.out
  ILINK.IlinkIcfFile: MIMX9352_cm33_ram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MIMX9352DVUXM_cm33; SDK_I2C_BASED_COMPONENT_USED=1; BOARD_USE_ADP5585=1; SERIAL_PORT_TYPE_UART=1; SDK_OS_FREE_RTOS; MCUXPRESSO_SDK
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  group source
    ../: freertos_lpspi_b2b_master.c FreeRTOSConfig.h
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group freertos/freertos-kernel
    ../../../../../../rtos/freertos/freertos-kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos-kernel/portable
    ../../../../../../rtos/freertos/freertos-kernel/portable/: readme.txt
  group freertos/freertos-kernel/portable/IAR/ARM_CM33_NTZ/non_secure
    ../../../../../../rtos/freertos/freertos-kernel/portable/IAR/ARM_CM33_NTZ/non_secure/: port.c portasm.h portasm.s portmacro.h portmacrocommon.h
  group freertos/freertos-kernel/portable/MemMang
    ../../../../../../rtos/freertos/freertos-kernel/portable/MemMang/: heap_4.c ReadMe.url
  group freertos/freertos-kernel/include
    ../../../../../../rtos/freertos/freertos-kernel/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stdint.readme stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
  group drivers
    ../../../../../../devices/MIMX9352/drivers/: fsl_lpi2c.c fsl_lpi2c.h fsl_clock.h fsl_clock.c fsl_lpspi.c fsl_lpspi.h fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_lpuart.h fsl_lpuart.c fsl_iomuxc.h fsl_rgpio.h fsl_rgpio.c fsl_cache.c fsl_cache.h fsl_sentinel.h fsl_sentinel.c
  group drivers/freertos
    ../../../../../../devices/MIMX9352/drivers/: fsl_lpspi_freertos.h fsl_lpspi_freertos.c
  group components/adp5585
    ../../../../../../components/adp5585/: fsl_adp5585.h fsl_adp5585.c
  group device
    ../../../../../../devices/MIMX9352/: fsl_device_registers.h MIMX9352_cm33.h MIMX9352_cm33_features.h system_MIMX9352_cm33.c system_MIMX9352_cm33.h
  group utilities
    ../../../../../../devices/MIMX9352/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../devices/MIMX9352/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../devices/MIMX9352/utilities/: fsl_assert.c
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/serial_manager
    ../../../../../../components/serial_manager/: fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group startup
    ../../../../../../devices/MIMX9352/iar/: startup_MIMX9352_cm33.s
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm33.h mpu_armv8.h tz_context.h
